# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\STM32F4;.\CMSIS\inc;.\Mylib\Inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Code
    ./Code/Src/: main.cpp
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group Startup
    ./Startup/: startup_stm32f407xx.s
  group Mylib
    ./Mylib/Src/: mylib.cpp
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c queue.c stream_buffer.c tasks.c timers.c port.c
